# Keil uVision project SE_Practica9_AlbaRueda_Lucia.uvproj, settings and files
target Practica9 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2378 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Blinky
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group Codigo de inicio
    ./: LPC2300.s
  group Llamadas a sistema
    ./: Retarget.c Serial.c
  group Codigo fuente
    ./: Practica9.c HAL.c
  group Documentation
    ./: Resumen.txt
  group Sistema Operativo
    ./: SOInstantUP.c
target LPC2378 Flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC2378 NXP (founded by Philips)
  cpu: as above
  output: Blinky
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
