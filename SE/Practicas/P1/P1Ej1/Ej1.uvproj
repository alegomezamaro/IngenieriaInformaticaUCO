# Keil uVision project Ej1.uvproj, settings and files
target Practica 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2378 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Ej1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group Codigo de Inicio
    ./: LPC2300.s
  group Llamadas a Sistema
    ./: Retarget.c Serial.c
  group Codigo Fuente
    ./: Practica1.c
  group Documentacion
    ./: Resumen.txt
